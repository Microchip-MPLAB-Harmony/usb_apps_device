# IAR project printer_basic_sam_9x60_ek_iar.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM9X60 Microchip SAM9X60
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 12
  General.FPU2: 0
  ICCARM.CCIncludePath2: ..\src; ..\src\config\sam_9x60_ek_iar; ..\src\packs\SAM9X60_DFP; .
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: harmony.bin
  ILINK.IlinkOutputFile: sam_9x60_ek_iar.out
  ILINK.IlinkIcfFile: ..\src\config\sam_9x60_ek_iar\ddram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  group Harmony3/Header Files
    ../src/: app.h
  group Harmony3/Header Files/config/sam_9x60_ek_iar
    ../src/config/sam_9x60_ek_iar/: configuration.h definitions.h device.h device_cache.h interrupts.h toolchain_specifics.h user.h
  group Harmony3/Header Files/config/sam_9x60_ek_iar/bsp
    ../src/config/sam_9x60_ek_iar/bsp/: bsp.h
  group Harmony3/Header Files/config/sam_9x60_ek_iar/driver
    ../src/config/sam_9x60_ek_iar/driver/: driver.h driver_common.h
  group Harmony3/Header Files/config/sam_9x60_ek_iar/driver/usart
    ../src/config/sam_9x60_ek_iar/driver/usart/: drv_usart.h drv_usart_definitions.h
  group Harmony3/Header Files/config/sam_9x60_ek_iar/driver/usb
    ../src/config/sam_9x60_ek_iar/driver/usb/: drv_usb.h
  group Harmony3/Header Files/config/sam_9x60_ek_iar/driver/usb/udphs
    ../src/config/sam_9x60_ek_iar/driver/usb/udphs/: drv_usb_udphs.h
  group Harmony3/Header Files/config/sam_9x60_ek_iar/driver/usb/udphs/src
    ../src/config/sam_9x60_ek_iar/driver/usb/udphs/src/: drv_usb_udphs_local.h drv_usb_udphs_variant_mapping.h
  group Harmony3/Header Files/config/sam_9x60_ek_iar/osal
    ../src/config/sam_9x60_ek_iar/osal/: osal.h osal_definitions.h osal_impl_basic.h
  group Harmony3/Header Files/config/sam_9x60_ek_iar/peripheral/aic
    ../src/config/sam_9x60_ek_iar/peripheral/aic/: plib_aic.h
  group Harmony3/Header Files/config/sam_9x60_ek_iar/peripheral/clk
    ../src/config/sam_9x60_ek_iar/peripheral/clk/: plib_clk.h
  group Harmony3/Header Files/config/sam_9x60_ek_iar/peripheral/dbgu
    ../src/config/sam_9x60_ek_iar/peripheral/dbgu/: plib_dbgu.h plib_dbgu_common.h
  group Harmony3/Header Files/config/sam_9x60_ek_iar/peripheral/mmu
    ../src/config/sam_9x60_ek_iar/peripheral/mmu/: cp15.h plib_mmu.h
  group Harmony3/Header Files/config/sam_9x60_ek_iar/peripheral/pio
    ../src/config/sam_9x60_ek_iar/peripheral/pio/: plib_pio.h
  group Harmony3/Header Files/config/sam_9x60_ek_iar/system
    ../src/config/sam_9x60_ek_iar/system/: system.h system_common.h system_module.h
  group Harmony3/Header Files/config/sam_9x60_ek_iar/system/cache
    ../src/config/sam_9x60_ek_iar/system/cache/: sys_cache.h
  group Harmony3/Header Files/config/sam_9x60_ek_iar/system/debug
    ../src/config/sam_9x60_ek_iar/system/debug/: sys_debug.h
  group Harmony3/Header Files/config/sam_9x60_ek_iar/system/dma
    ../src/config/sam_9x60_ek_iar/system/dma/: sys_dma.h sys_dma_mapping.h
  group Harmony3/Header Files/config/sam_9x60_ek_iar/system/int
    ../src/config/sam_9x60_ek_iar/system/int/: sys_int.h sys_int_mapping.h
  group Harmony3/Header Files/config/sam_9x60_ek_iar/usb
    ../src/config/sam_9x60_ek_iar/usb/: usb_chapter_9.h usb_common.h usb_device.h usb_device_printer.h usb_host.h usb_host_client_driver.h usb_host_hub_interface.h usb_hub.h usb_printer.h
  group Harmony3/Header Files/config/sam_9x60_ek_iar/usb/src
    ../src/config/sam_9x60_ek_iar/usb/src/: usb_device_function_driver.h usb_device_local.h usb_device_mapping.h usb_device_printer_local.h usb_external_dependencies.h
  group Harmony3/Header Files/packs/SAM9X60_DFP
    ../src/packs/SAM9X60_DFP/: sam9x60.h
  group Harmony3/Header Files/packs/SAM9X60_DFP/component
    ../src/packs/SAM9X60_DFP/component/: adc.h aes.h aic.h bsc.h can.h classd.h dbgu.h emac.h flexcom.h gfx2d.h gpbr.h i2smcc.h isi.h lcdc.h matrix.h mpddrc.h otpc.h pio.h pit.h pit64b.h pmc.h pmecc.h pmerrloc.h pwm.h qspi.h rstc.h rtc.h rtt.h sckc.h sdmmc.h sdramc.h sfr.h sha.h shdwc.h smc.h ssc.h syscwp.h tc.h tdes.h trng.h udphs.h uhpfs.h uhphs.h wdt.h xdmac.h
  group Harmony3/Header Files/packs/SAM9X60_DFP/instance
    ../src/packs/SAM9X60_DFP/instance/: adc.h aes.h aic.h bsc.h can0.h can1.h classd.h dbgu.h emac0.h emac1.h flexcom0.h flexcom1.h flexcom10.h flexcom11.h flexcom12.h flexcom2.h flexcom3.h flexcom4.h flexcom5.h flexcom6.h flexcom7.h flexcom8.h flexcom9.h gfx2d.h gpbr.h i2smcc.h isi.h lcdc.h matrix.h mpddrc.h otpc.h pioa.h piob.h pioc.h piod.h pit.h pit64b.h pmc.h pmecc.h pmerrloc.h pwm.h qspi.h rstc.h rtc.h rtt.h sckc.h sdmmc0.h sdmmc1.h sdramc.h sfr.h sha.h shdwc.h smc.h ssc.h syscwp.h tc0.h tc1.h tdes.h trng.h udphs.h uhphs_ehci.h uhphs_ohci.h wdt.h xdmac.h
  group Harmony3/Header Files/packs/SAM9X60_DFP/pio
    ../src/packs/SAM9X60_DFP/pio/: sam9x60.h
  group Harmony3/Linker File
    ../src/config/sam_9x60_ek_iar/: ddram.icf
  group Harmony3/Source Files
    ../src/: app.c main.c
  group Harmony3/Source Files/config/sam_9x60_ek_iar
    ../src/config/sam_9x60_ek_iar/: cstartup.s initialization.c interrupts.c tasks.c usb_device_init_data.c vectortrap.s
  group Harmony3/Source Files/config/sam_9x60_ek_iar/bsp
    ../src/config/sam_9x60_ek_iar/bsp/: bsp.c
  group Harmony3/Source Files/config/sam_9x60_ek_iar/driver/usart
    ../src/config/sam_9x60_ek_iar/driver/usart/src/: drv_usart.c drv_usart_local.h
  group Harmony3/Source Files/config/sam_9x60_ek_iar/driver/usb/udphs/src
    ../src/config/sam_9x60_ek_iar/driver/usb/udphs/src/: drv_usb_udphs.c drv_usb_udphs_device.c
  group Harmony3/Source Files/config/sam_9x60_ek_iar/peripheral/aic
    ../src/config/sam_9x60_ek_iar/peripheral/aic/: plib_aic.c
  group Harmony3/Source Files/config/sam_9x60_ek_iar/peripheral/clk
    ../src/config/sam_9x60_ek_iar/peripheral/clk/: plib_clk.c
  group Harmony3/Source Files/config/sam_9x60_ek_iar/peripheral/dbgu
    ../src/config/sam_9x60_ek_iar/peripheral/dbgu/: plib_dbgu.c
  group Harmony3/Source Files/config/sam_9x60_ek_iar/peripheral/mmu
    ../src/config/sam_9x60_ek_iar/peripheral/mmu/: plib_mmu.c
  group Harmony3/Source Files/config/sam_9x60_ek_iar/peripheral/pio
    ../src/config/sam_9x60_ek_iar/peripheral/pio/: plib_pio.c
  group Harmony3/Source Files/config/sam_9x60_ek_iar/stdio
    ../src/config/sam_9x60_ek_iar/stdio/: iar_monitor.c
  group Harmony3/Source Files/config/sam_9x60_ek_iar/system/cache
    ../src/config/sam_9x60_ek_iar/system/cache/: sys_cache.c
  group Harmony3/Source Files/config/sam_9x60_ek_iar/system/dma
    ../src/config/sam_9x60_ek_iar/system/dma/: sys_dma.c
  group Harmony3/Source Files/config/sam_9x60_ek_iar/system/int
    ../src/config/sam_9x60_ek_iar/system/int/src/: sys_int.c
  group Harmony3/Source Files/config/sam_9x60_ek_iar/usb/src
    ../src/config/sam_9x60_ek_iar/usb/src/: usb_device.c usb_device_printer.c
