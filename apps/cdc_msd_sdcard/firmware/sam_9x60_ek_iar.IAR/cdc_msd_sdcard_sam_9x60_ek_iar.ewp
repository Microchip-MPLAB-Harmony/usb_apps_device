# IAR project cdc_msd_sdcard_sam_9x60_ek_iar.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM9X60 Microchip SAM9X60
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 12
  General.FPU2: 0
  ICCARM.CCIncludePath2: ..\src; ..\src\config\sam_9x60_ek_iar; ..\src\packs\SAM9X60_DFP; ..\src\packs\CMSIS\CMSIS\Core\Include; ..\src\packs\CMSIS; ..\..\firmware\src; ..\..\firmware\src\config\sam_9x60_ek_iar; ..\..\firmware\src\packs\SAM9X60_DFP; ..\..\firmware\src\packs\CMSIS\CMSIS\Core\Include; ..\..\firmware\src\packs\CMSIS; ..\..\firmware\src\arm
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\..\firmware\src; ..\..\firmware\src\config\sam_9x60_ek_iar; ..\..\firmware\src\packs\SAM9X60_DFP; ..\..\firmware\src\packs\CMSIS\CMSIS\Core\Include; ..\..\firmware\src\packs\CMSIS; ..\..\firmware\src\arm
  OBJCOPY.OOCOutputFile: harmony.bin
  ILINK.IlinkOutputFile: cdc_msd_sdcard_sam_9x60_ek_iar.out
  ILINK.IlinkIcfFile: ..\src\config\sam_9x60_ek_iar\ddram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  group Harmony3/Header Files
    ../src/: app.h
  group Harmony3/Header Files/config/sam_9x60_ek_iar
    ../src/config/sam_9x60_ek_iar/: device_cache.h toolchain_specifics.h definitions.h interrupts.h device.h user.h configuration.h
  group Harmony3/Header Files/config/sam_9x60_ek_iar/driver
    ../src/config/sam_9x60_ek_iar/driver/: driver.h driver_common.h
  group Harmony3/Header Files/config/sam_9x60_ek_iar/driver/usb
    ../src/config/sam_9x60_ek_iar/driver/usb/: drv_usb.h
  group Harmony3/Header Files/config/sam_9x60_ek_iar/driver/usb/udphs
    ../src/config/sam_9x60_ek_iar/driver/usb/udphs/: drv_usb_udphs.h
  group Harmony3/Header Files/config/sam_9x60_ek_iar/driver/usb/udphs/src
    ../src/config/sam_9x60_ek_iar/driver/usb/udphs/src/: drv_usb_udphs_variant_mapping.h drv_usb_udphs_local.h
  group Harmony3/Header Files/config/sam_9x60_ek_iar/driver/sdmmc
    ../src/config/sam_9x60_ek_iar/driver/sdmmc/: drv_sdmmc.h drv_sdmmc_definitions.h
    ../src/config/sam_9x60_ek_iar/driver/sdmmc/src/: drv_sdmmc_local.h
  group Harmony3/Header Files/config/sam_9x60_ek_iar/usb
    ../src/config/sam_9x60_ek_iar/usb/: usb_host_client_driver.h usb_host_hub_interface.h usb_host.h usb_hub.h usb_device_msd.h usb_msd.h scsi.h usb_device.h usb_common.h usb_chapter_9.h usb_device_cdc.h usb_cdc.h
  group Harmony3/Header Files/config/sam_9x60_ek_iar/usb/src
    ../src/config/sam_9x60_ek_iar/usb/src/: usb_device_msd_local.h usb_device_local.h usb_device_mapping.h usb_device_function_driver.h usb_external_dependencies.h usb_device_cdc_local.h
  group Harmony3/Header Files/config/sam_9x60_ek_iar/bsp
    ../src/config/sam_9x60_ek_iar/bsp/: bsp.h
  group Harmony3/Header Files/config/sam_9x60_ek_iar/peripheral/pit
    ../src/config/sam_9x60_ek_iar/peripheral/pit/: plib_pit.h
  group Harmony3/Header Files/config/sam_9x60_ek_iar/peripheral/mmu
    ../src/config/sam_9x60_ek_iar/peripheral/mmu/: plib_mmu.h cp15.h
  group Harmony3/Header Files/config/sam_9x60_ek_iar/peripheral/clk
    ../src/config/sam_9x60_ek_iar/peripheral/clk/: plib_clk.h
  group Harmony3/Header Files/config/sam_9x60_ek_iar/peripheral/pio
    ../src/config/sam_9x60_ek_iar/peripheral/pio/: plib_pio.h
  group Harmony3/Header Files/config/sam_9x60_ek_iar/peripheral/aic
    ../src/config/sam_9x60_ek_iar/peripheral/aic/: plib_aic.h
  group Harmony3/Header Files/config/sam_9x60_ek_iar/peripheral/tc
    ../src/config/sam_9x60_ek_iar/peripheral/tc/: plib_tc0.h plib_tc_common.h
  group Harmony3/Header Files/config/sam_9x60_ek_iar/peripheral/sdmmc
    ../src/config/sam_9x60_ek_iar/peripheral/sdmmc/: plib_sdmmc_common.h plib_sdmmc0.h
  group Harmony3/Header Files/config/sam_9x60_ek_iar/system
    ../src/config/sam_9x60_ek_iar/system/: system.h system_common.h system_module.h system_media.h
  group Harmony3/Header Files/config/sam_9x60_ek_iar/system/time
    ../src/config/sam_9x60_ek_iar/system/time/: sys_time.h sys_time_definitions.h
    ../src/config/sam_9x60_ek_iar/system/time/src/: sys_time_local.h
  group Harmony3/Header Files/config/sam_9x60_ek_iar/system/int
    ../src/config/sam_9x60_ek_iar/system/int/: sys_int.h sys_int_mapping.h
  group Harmony3/Header Files/config/sam_9x60_ek_iar/system/cache
    ../src/config/sam_9x60_ek_iar/system/cache/: sys_cache.h
  group Harmony3/Header Files/config/sam_9x60_ek_iar/system/debug
    ../src/config/sam_9x60_ek_iar/system/debug/: sys_debug.h
  group Harmony3/Header Files/config/sam_9x60_ek_iar/osal
    ../src/config/sam_9x60_ek_iar/osal/: osal.h osal_definitions.h osal_impl_basic.h
  group Harmony3/Header Files/packs/SAM9X60_DFP
    ../src/packs/SAM9X60_DFP/: sam9x60.h
  group Harmony3/Header Files/packs/SAM9X60_DFP/component
    ../src/packs/SAM9X60_DFP/component/: adc.h aes.h aic.h bsc.h can.h classd.h dbgu.h emac.h flexcom.h gfx2d.h gpbr.h i2smcc.h isi.h lcdc.h matrix.h mpddrc.h otpc.h pio.h pit.h pit64b.h pmc.h pmecc.h pmerrloc.h pwm.h qspi.h rstc.h rtc.h rtt.h sckc.h sdmmc.h sdramc.h sfr.h sha.h shdwc.h smc.h ssc.h syscwp.h tc.h tdes.h trng.h udphs.h uhpfs.h uhphs.h wdt.h xdmac.h
  group Harmony3/Header Files/packs/SAM9X60_DFP/instance
    ../src/packs/SAM9X60_DFP/instance/: adc.h aes.h aic.h bsc.h can0.h can1.h classd.h dbgu.h emac0.h emac1.h flexcom0.h flexcom1.h flexcom10.h flexcom11.h flexcom12.h flexcom2.h flexcom3.h flexcom4.h flexcom5.h flexcom6.h flexcom7.h flexcom8.h flexcom9.h gfx2d.h gpbr.h i2smcc.h isi.h lcdc.h matrix.h mpddrc.h otpc.h pioa.h piob.h pioc.h piod.h pit.h pit64b.h pmc.h pmecc.h pmerrloc.h pwm.h qspi.h rstc.h rtc.h rtt.h sckc.h sdmmc0.h sdmmc1.h sdramc.h sfr.h sha.h shdwc.h smc.h ssc.h syscwp.h tc0.h tc1.h tdes.h trng.h udphs.h uhphs_ehci.h uhphs_ohci.h wdt.h xdmac.h
  group Harmony3/Header Files/packs/SAM9X60_DFP/pio
    ../src/packs/SAM9X60_DFP/pio/: sam9x60.h
  group Harmony3/Source Files
    ../src/: main.c app.c
  group Harmony3/Source Files/config/sam_9x60_ek_iar
    ../src/config/sam_9x60_ek_iar/: initialization.c interrupts.c cstartup.s vectortrap.s usb_device_init_data.c tasks.c
  group Harmony3/Source Files/config/sam_9x60_ek_iar/driver/usb/udphs/src
    ../src/config/sam_9x60_ek_iar/driver/usb/udphs/src/: drv_usb_udphs.c drv_usb_udphs_device.c
  group Harmony3/Source Files/config/sam_9x60_ek_iar/driver/sdmmc
    ../src/config/sam_9x60_ek_iar/driver/sdmmc/src/: drv_sdmmc.c
  group Harmony3/Source Files/config/sam_9x60_ek_iar/bsp
    ../src/config/sam_9x60_ek_iar/bsp/: bsp.c
  group Harmony3/Source Files/config/sam_9x60_ek_iar/usb/src
    ../src/config/sam_9x60_ek_iar/usb/src/: usb_device_msd.c usb_device.c usb_device_cdc.c usb_device_cdc_acm.c
  group Harmony3/Source Files/config/sam_9x60_ek_iar/peripheral/pit
    ../src/config/sam_9x60_ek_iar/peripheral/pit/: plib_pit.c
  group Harmony3/Source Files/config/sam_9x60_ek_iar/peripheral/mmu
    ../src/config/sam_9x60_ek_iar/peripheral/mmu/: plib_mmu.c
  group Harmony3/Source Files/config/sam_9x60_ek_iar/peripheral/clk
    ../src/config/sam_9x60_ek_iar/peripheral/clk/: plib_clk.c
  group Harmony3/Source Files/config/sam_9x60_ek_iar/peripheral/pio
    ../src/config/sam_9x60_ek_iar/peripheral/pio/: plib_pio.c
  group Harmony3/Source Files/config/sam_9x60_ek_iar/peripheral/aic
    ../src/config/sam_9x60_ek_iar/peripheral/aic/: plib_aic.c
  group Harmony3/Source Files/config/sam_9x60_ek_iar/peripheral/tc
    ../src/config/sam_9x60_ek_iar/peripheral/tc/: plib_tc0.c
  group Harmony3/Source Files/config/sam_9x60_ek_iar/peripheral/sdmmc
    ../src/config/sam_9x60_ek_iar/peripheral/sdmmc/: plib_sdmmc0.c
  group Harmony3/Source Files/config/sam_9x60_ek_iar/stdio
    ../src/config/sam_9x60_ek_iar/stdio/: iar_monitor.c
  group Harmony3/Source Files/config/sam_9x60_ek_iar/system/time
    ../src/config/sam_9x60_ek_iar/system/time/src/: sys_time.c
  group Harmony3/Source Files/config/sam_9x60_ek_iar/system/int
    ../src/config/sam_9x60_ek_iar/system/int/src/: sys_int.c
  group Harmony3/Source Files/config/sam_9x60_ek_iar/system/cache
    ../src/config/sam_9x60_ek_iar/system/cache/: sys_cache.c
  group Harmony3/Linker File
    ../src/config/sam_9x60_ek_iar/: ddram.icf
