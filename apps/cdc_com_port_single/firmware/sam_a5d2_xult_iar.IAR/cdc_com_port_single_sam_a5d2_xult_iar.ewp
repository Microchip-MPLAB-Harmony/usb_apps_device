# IAR project cdc_com_port_single_sam_a5d2_xult_iar.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMA5D27 Microchip ATSAMA5D27
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 50
  General.FPU2: 5
  ICCARM.CCIncludePath2: ..\src; ..\src\config\sam_a5d2_xult_iar; ..\src\packs\ATSAMA5D27_DFP; ..\src\packs\CMSIS\CMSIS\Core_A\Include; ..\src\packs\CMSIS
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: harmony.bin
  ILINK.IlinkOutputFile: sam_a5d2_xult_iar.out
  ILINK.IlinkIcfFile: ..\src\config\sam_a5d2_xult_iar\ddr.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptStrategy: 0
  group Harmony3/Header Files
    ../src/: app.h
  group Harmony3/Header Files/config/sam_a5d2_xult_iar
    ../src/config/sam_a5d2_xult_iar/: configuration.h definitions.h device.h device_cache.h interrupts.h toolchain_specifics.h user.h
  group Harmony3/Header Files/config/sam_a5d2_xult_iar/bsp
    ../src/config/sam_a5d2_xult_iar/bsp/: bsp.h
  group Harmony3/Header Files/config/sam_a5d2_xult_iar/driver
    ../src/config/sam_a5d2_xult_iar/driver/: driver.h driver_common.h
  group Harmony3/Header Files/config/sam_a5d2_xult_iar/driver/usb
    ../src/config/sam_a5d2_xult_iar/driver/usb/: drv_usb.h
  group Harmony3/Header Files/config/sam_a5d2_xult_iar/driver/usb/udphs
    ../src/config/sam_a5d2_xult_iar/driver/usb/udphs/: drv_usb_udphs.h
  group Harmony3/Header Files/config/sam_a5d2_xult_iar/driver/usb/udphs/src
    ../src/config/sam_a5d2_xult_iar/driver/usb/udphs/src/: drv_usb_udphs_local.h drv_usb_udphs_variant_mapping.h
  group Harmony3/Header Files/config/sam_a5d2_xult_iar/osal
    ../src/config/sam_a5d2_xult_iar/osal/: osal.h osal_definitions.h osal_impl_basic.h
  group Harmony3/Header Files/config/sam_a5d2_xult_iar/peripheral/aic
    ../src/config/sam_a5d2_xult_iar/peripheral/aic/: plib_aic.h
  group Harmony3/Header Files/config/sam_a5d2_xult_iar/peripheral/clk
    ../src/config/sam_a5d2_xult_iar/peripheral/clk/: plib_clk.h
  group Harmony3/Header Files/config/sam_a5d2_xult_iar/peripheral/l2cc
    ../src/config/sam_a5d2_xult_iar/peripheral/l2cc/: plib_l2cc.h
  group Harmony3/Header Files/config/sam_a5d2_xult_iar/peripheral/matrix
    ../src/config/sam_a5d2_xult_iar/peripheral/matrix/: plib_matrix.h
  group Harmony3/Header Files/config/sam_a5d2_xult_iar/peripheral/mmu
    ../src/config/sam_a5d2_xult_iar/peripheral/mmu/: plib_mmu.h
  group Harmony3/Header Files/config/sam_a5d2_xult_iar/peripheral/pio
    ../src/config/sam_a5d2_xult_iar/peripheral/pio/: plib_pio.h
  group Harmony3/Header Files/config/sam_a5d2_xult_iar/system
    ../src/config/sam_a5d2_xult_iar/system/: system.h system_common.h system_module.h
  group Harmony3/Header Files/config/sam_a5d2_xult_iar/system/cache
    ../src/config/sam_a5d2_xult_iar/system/cache/: sys_cache.h
  group Harmony3/Header Files/config/sam_a5d2_xult_iar/system/debug
    ../src/config/sam_a5d2_xult_iar/system/debug/: sys_debug.h
  group Harmony3/Header Files/config/sam_a5d2_xult_iar/system/int
    ../src/config/sam_a5d2_xult_iar/system/int/: sys_int.h sys_int_mapping.h
  group Harmony3/Header Files/config/sam_a5d2_xult_iar/usb
    ../src/config/sam_a5d2_xult_iar/usb/: usb_cdc.h usb_chapter_9.h usb_common.h usb_device.h usb_device_cdc.h usb_host.h usb_host_client_driver.h usb_host_hub_interface.h usb_hub.h
  group Harmony3/Header Files/config/sam_a5d2_xult_iar/usb/src
    ../src/config/sam_a5d2_xult_iar/usb/src/: usb_device_cdc_local.h usb_device_function_driver.h usb_device_local.h usb_device_mapping.h usb_external_dependencies.h
  group Harmony3/Header Files/packs/ATSAMA5D27_DFP
    ../src/packs/ATSAMA5D27_DFP/: sama5d27.h
  group Harmony3/Header Files/packs/ATSAMA5D27_DFP/component
    ../src/packs/ATSAMA5D27_DFP/component/: acc.h adc.h aes.h aesb.h aic.h aximx.h chipid.h classd.h flexcom.h gmac.h i2sc.h icm.h isc.h l2cc.h lcdc.h matrix.h mcan.h mpddrc.h pdmic.h pio.h pit.h pmc.h ptc.h pwm.h qspi.h rstc.h rtc.h rxlp.h sckc.h sdmmc.h secumod.h sfc.h sfr.h sfrbu.h sha.h shdwc.h smc.h spi.h ssc.h tc.h tdes.h trng.h twihs.h uart.h udphs.h uhphs.h wdt.h xdmac.h
  group Harmony3/Header Files/packs/ATSAMA5D27_DFP/instance
    ../src/packs/ATSAMA5D27_DFP/instance/: acc.h adc.h aes.h aesb.h aic.h aximx.h chipid.h classd.h flexcom0.h flexcom1.h flexcom2.h flexcom3.h flexcom4.h gmac.h i2sc0.h i2sc1.h icm.h isc.h l2cc.h lcdc.h matrix0.h matrix1.h mcan0.h mcan1.h mpddrc.h pdmic.h pio.h pit.h pmc.h ptc.h pwm.h qspi0.h qspi1.h rstc.h rtc.h rxlp.h saic.h sckc.h sdmmc0.h sdmmc1.h secumod.h sfc.h sfr.h sfrbu.h sha.h shdwc.h smc.h spi0.h spi1.h ssc0.h ssc1.h tc0.h tc1.h tdes.h trng.h twihs0.h twihs1.h uart0.h uart1.h uart2.h uart3.h uart4.h udphs.h wdt.h xdmac0.h xdmac1.h
  group Harmony3/Header Files/packs/ATSAMA5D27_DFP/pio
    ../src/packs/ATSAMA5D27_DFP/pio/: sama5d27.h
  group Harmony3/Header Files/packs/CMSIS/CMSIS/Core_A/Include
    ../src/packs/CMSIS/CMSIS/Core_A/Include/: cmsis_compiler.h cmsis_cp15.h cmsis_gcc.h cmsis_iccarm.h core_ca.h
  group Harmony3/Linker File
    ../src/config/sam_a5d2_xult_iar/: ddr.icf
  group Harmony3/Source Files
    ../src/: app.c main.c
  group Harmony3/Source Files/config/sam_a5d2_xult_iar
    ../src/config/sam_a5d2_xult_iar/: cstartup.s fault_handlers.c initialization.c interrupts.c tasks.c usb_device_init_data.c
  group Harmony3/Source Files/config/sam_a5d2_xult_iar/bsp
    ../src/config/sam_a5d2_xult_iar/bsp/: bsp.c
  group Harmony3/Source Files/config/sam_a5d2_xult_iar/driver/usb/udphs/src
    ../src/config/sam_a5d2_xult_iar/driver/usb/udphs/src/: drv_usb_udphs.c drv_usb_udphs_device.c
  group Harmony3/Source Files/config/sam_a5d2_xult_iar/peripheral/aic
    ../src/config/sam_a5d2_xult_iar/peripheral/aic/: plib_aic.c
  group Harmony3/Source Files/config/sam_a5d2_xult_iar/peripheral/clk
    ../src/config/sam_a5d2_xult_iar/peripheral/clk/: plib_clk.c
  group Harmony3/Source Files/config/sam_a5d2_xult_iar/peripheral/l2cc
    ../src/config/sam_a5d2_xult_iar/peripheral/l2cc/: plib_l2cc.c
  group Harmony3/Source Files/config/sam_a5d2_xult_iar/peripheral/matrix
    ../src/config/sam_a5d2_xult_iar/peripheral/matrix/: plib_matrix.c
  group Harmony3/Source Files/config/sam_a5d2_xult_iar/peripheral/mmu
    ../src/config/sam_a5d2_xult_iar/peripheral/mmu/: plib_mmu.c
  group Harmony3/Source Files/config/sam_a5d2_xult_iar/peripheral/pio
    ../src/config/sam_a5d2_xult_iar/peripheral/pio/: plib_pio.c
  group Harmony3/Source Files/config/sam_a5d2_xult_iar/stdio
    ../src/config/sam_a5d2_xult_iar/stdio/: iar_monitor.c
  group Harmony3/Source Files/config/sam_a5d2_xult_iar/system/cache
    ../src/config/sam_a5d2_xult_iar/system/cache/: sys_cache.c
  group Harmony3/Source Files/config/sam_a5d2_xult_iar/system/int
    ../src/config/sam_a5d2_xult_iar/system/int/src/: sys_int.c
  group Harmony3/Source Files/config/sam_a5d2_xult_iar/usb/src
    ../src/config/sam_a5d2_xult_iar/usb/src/: usb_device.c usb_device_cdc.c usb_device_cdc_acm.c
