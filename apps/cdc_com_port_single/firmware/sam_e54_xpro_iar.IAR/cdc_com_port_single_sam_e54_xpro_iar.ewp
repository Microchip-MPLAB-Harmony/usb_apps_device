# IAR project cdc_com_port_single_sam_e54_xpro_iar.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAME54P20A Microchip ATSAME54P20A
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCIncludePath2: ..\src; ..\src\config\sam_e54_xpro_iar; ..\src\packs\ATSAME54P20A_DFP; ..\src\packs\CMSIS\CMSIS\Core\Include; ..\src\packs\CMSIS
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: sam_e54_xpro_iar.out
  ILINK.IlinkIcfFile: ..\src\config\sam_e54_xpro_iar\flash.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  group Harmony3/Header Files
    ../src/: app.h
  group Harmony3/Header Files/config/sam_e54_xpro_iar
    ../src/config/sam_e54_xpro_iar/: configuration.h definitions.h device.h device_cache.h device_vectors.h interrupts.h toolchain_specifics.h user.h
  group Harmony3/Header Files/config/sam_e54_xpro_iar/bsp
    ../src/config/sam_e54_xpro_iar/bsp/: bsp.h
  group Harmony3/Header Files/config/sam_e54_xpro_iar/driver
    ../src/config/sam_e54_xpro_iar/driver/: driver.h driver_common.h
  group Harmony3/Header Files/config/sam_e54_xpro_iar/driver/usb
    ../src/config/sam_e54_xpro_iar/driver/usb/: drv_usb.h drv_usb_external_dependencies.h
  group Harmony3/Header Files/config/sam_e54_xpro_iar/driver/usb/usbfsv1
    ../src/config/sam_e54_xpro_iar/driver/usb/usbfsv1/: drv_usbfsv1.h
  group Harmony3/Header Files/config/sam_e54_xpro_iar/driver/usb/usbfsv1/src
    ../src/config/sam_e54_xpro_iar/driver/usb/usbfsv1/src/: drv_usbfsv1_local.h drv_usbfsv1_variant_mapping.h
  group Harmony3/Header Files/config/sam_e54_xpro_iar/osal
    ../src/config/sam_e54_xpro_iar/osal/: osal.h osal_definitions.h osal_impl_basic.h
  group Harmony3/Header Files/config/sam_e54_xpro_iar/peripheral/clock
    ../src/config/sam_e54_xpro_iar/peripheral/clock/: plib_clock.h
  group Harmony3/Header Files/config/sam_e54_xpro_iar/peripheral/cmcc
    ../src/config/sam_e54_xpro_iar/peripheral/cmcc/: plib_cmcc.h
  group Harmony3/Header Files/config/sam_e54_xpro_iar/peripheral/evsys
    ../src/config/sam_e54_xpro_iar/peripheral/evsys/: plib_evsys.h
  group Harmony3/Header Files/config/sam_e54_xpro_iar/peripheral/nvic
    ../src/config/sam_e54_xpro_iar/peripheral/nvic/: plib_nvic.h
  group Harmony3/Header Files/config/sam_e54_xpro_iar/peripheral/nvmctrl
    ../src/config/sam_e54_xpro_iar/peripheral/nvmctrl/: plib_nvmctrl.h
  group Harmony3/Header Files/config/sam_e54_xpro_iar/peripheral/port
    ../src/config/sam_e54_xpro_iar/peripheral/port/: plib_port.h
  group Harmony3/Header Files/config/sam_e54_xpro_iar/system
    ../src/config/sam_e54_xpro_iar/system/: system.h system_common.h system_module.h
  group Harmony3/Header Files/config/sam_e54_xpro_iar/system/cache
    ../src/config/sam_e54_xpro_iar/system/cache/: sys_cache.h
  group Harmony3/Header Files/config/sam_e54_xpro_iar/system/debug
    ../src/config/sam_e54_xpro_iar/system/debug/: sys_debug.h
  group Harmony3/Header Files/config/sam_e54_xpro_iar/system/int
    ../src/config/sam_e54_xpro_iar/system/int/: sys_int.h sys_int_mapping.h
  group Harmony3/Header Files/config/sam_e54_xpro_iar/usb
    ../src/config/sam_e54_xpro_iar/usb/: usb_cdc.h usb_chapter_9.h usb_common.h usb_device.h usb_device_cdc.h usb_host.h usb_host_client_driver.h usb_host_hub_interface.h usb_hub.h
  group Harmony3/Header Files/config/sam_e54_xpro_iar/usb/src
    ../src/config/sam_e54_xpro_iar/usb/src/: usb_device_cdc_local.h usb_device_function_driver.h usb_device_local.h usb_device_mapping.h usb_external_dependencies.h
  group Harmony3/Header Files/packs/ATSAME54P20A_DFP
    ../src/packs/ATSAME54P20A_DFP/: same54p20a.h
  group Harmony3/Header Files/packs/ATSAME54P20A_DFP/component
    ../src/packs/ATSAME54P20A_DFP/component/: ac.h adc.h aes.h can.h ccl.h cmcc.h dac.h dmac.h dsu.h eic.h evsys.h freqm.h gclk.h gmac.h hmatrixb.h i2s.h icm.h mclk.h nvmctrl.h osc32kctrl.h oscctrl.h pac.h pcc.h pdec.h pm.h port.h pukcc.h qspi.h ramecc.h rstc.h rtc.h sdhc.h sercom.h supc.h tc.h tcc.h trng.h usb.h wdt.h
  group Harmony3/Header Files/packs/ATSAME54P20A_DFP/instance
    ../src/packs/ATSAME54P20A_DFP/instance/: ac.h adc0.h adc1.h aes.h can0.h can1.h ccl.h cmcc.h dac.h dmac.h dsu.h eic.h evsys.h freqm.h gclk.h gmac.h hmatrix.h i2s.h icm.h mclk.h nvmctrl.h osc32kctrl.h oscctrl.h pac.h pcc.h pdec.h pm.h port.h qspi.h ramecc.h rstc.h rtc.h sdhc0.h sdhc1.h sercom0.h sercom1.h sercom2.h sercom3.h sercom4.h sercom5.h sercom6.h sercom7.h supc.h tc0.h tc1.h tc2.h tc3.h tc4.h tc5.h tc6.h tc7.h tcc0.h tcc1.h tcc2.h tcc3.h tcc4.h trng.h usb.h wdt.h
  group Harmony3/Header Files/packs/ATSAME54P20A_DFP/pio
    ../src/packs/ATSAME54P20A_DFP/pio/: same54p20a.h
  group Harmony3/Header Files/packs/CMSIS/CMSIS/Core/Include
    ../src/packs/CMSIS/CMSIS/Core/Include/: cachel1_armv7.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_cm4.h mpu_armv7.h
  group Harmony3/Linker File
    ../src/config/sam_e54_xpro_iar/: flash.icf
  group Harmony3/Source Files
    ../src/: app.c main.c
  group Harmony3/Source Files/config/sam_e54_xpro_iar
    ../src/config/sam_e54_xpro_iar/: exceptions.c initialization.c interrupts.c startup_iar.c tasks.c usb_device_init_data.c
  group Harmony3/Source Files/config/sam_e54_xpro_iar/bsp
    ../src/config/sam_e54_xpro_iar/bsp/: bsp.c
  group Harmony3/Source Files/config/sam_e54_xpro_iar/driver/usb/usbfsv1/src
    ../src/config/sam_e54_xpro_iar/driver/usb/usbfsv1/src/: drv_usbfsv1.c drv_usbfsv1_device.c
  group Harmony3/Source Files/config/sam_e54_xpro_iar/peripheral/clock
    ../src/config/sam_e54_xpro_iar/peripheral/clock/: plib_clock.c
  group Harmony3/Source Files/config/sam_e54_xpro_iar/peripheral/cmcc
    ../src/config/sam_e54_xpro_iar/peripheral/cmcc/: plib_cmcc.c
  group Harmony3/Source Files/config/sam_e54_xpro_iar/peripheral/evsys
    ../src/config/sam_e54_xpro_iar/peripheral/evsys/: plib_evsys.c
  group Harmony3/Source Files/config/sam_e54_xpro_iar/peripheral/nvic
    ../src/config/sam_e54_xpro_iar/peripheral/nvic/: plib_nvic.c
  group Harmony3/Source Files/config/sam_e54_xpro_iar/peripheral/nvmctrl
    ../src/config/sam_e54_xpro_iar/peripheral/nvmctrl/: plib_nvmctrl.c
  group Harmony3/Source Files/config/sam_e54_xpro_iar/peripheral/port
    ../src/config/sam_e54_xpro_iar/peripheral/port/: plib_port.c
  group Harmony3/Source Files/config/sam_e54_xpro_iar/stdio
    ../src/config/sam_e54_xpro_iar/stdio/: iar_monitor.c
  group Harmony3/Source Files/config/sam_e54_xpro_iar/system/cache
    ../src/config/sam_e54_xpro_iar/system/cache/: sys_cache.c
  group Harmony3/Source Files/config/sam_e54_xpro_iar/system/int
    ../src/config/sam_e54_xpro_iar/system/int/src/: sys_int.c
  group Harmony3/Source Files/config/sam_e54_xpro_iar/usb/src
    ../src/config/sam_e54_xpro_iar/usb/src/: usb_device.c usb_device_cdc.c usb_device_cdc_acm.c
