# IAR project cdc_com_port_single_sam_d21_xpro_iar.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMD21J18A Microchip ATSAMD21J18A
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCIncludePath2: ..\src; ..\src\config\sam_d21_xpro_iar; ..\src\packs\ATSAMD21J18A_DFP; ..\src\packs\CMSIS\CMSIS\Core\Include; ..\src\packs\CMSIS
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: sam_d21_xpro_iar.out
  ILINK.IlinkIcfFile: ..\src\config\sam_d21_xpro_iar\flash.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Harmony3/Header Files
    ../src/: app.h
  group Harmony3/Header Files/config/sam_d21_xpro_iar
    ../src/config/sam_d21_xpro_iar/: device.h device_cache.h toolchain_specifics.h definitions.h interrupts.h device_vectors.h user.h configuration.h
  group Harmony3/Header Files/config/sam_d21_xpro_iar/bsp
    ../src/config/sam_d21_xpro_iar/bsp/: bsp.h
  group Harmony3/Header Files/config/sam_d21_xpro_iar/peripheral/nvmctrl
    ../src/config/sam_d21_xpro_iar/peripheral/nvmctrl/: plib_nvmctrl.h
  group Harmony3/Header Files/config/sam_d21_xpro_iar/peripheral/evsys
    ../src/config/sam_d21_xpro_iar/peripheral/evsys/: plib_evsys.h
  group Harmony3/Header Files/config/sam_d21_xpro_iar/peripheral/port
    ../src/config/sam_d21_xpro_iar/peripheral/port/: plib_port.h
  group Harmony3/Header Files/config/sam_d21_xpro_iar/peripheral/clock
    ../src/config/sam_d21_xpro_iar/peripheral/clock/: plib_clock.h
  group Harmony3/Header Files/config/sam_d21_xpro_iar/peripheral/nvic
    ../src/config/sam_d21_xpro_iar/peripheral/nvic/: plib_nvic.h
  group Harmony3/Header Files/config/sam_d21_xpro_iar/driver
    ../src/config/sam_d21_xpro_iar/driver/: driver.h driver_common.h
  group Harmony3/Header Files/config/sam_d21_xpro_iar/driver/usb
    ../src/config/sam_d21_xpro_iar/driver/usb/: drv_usb.h drv_usb_external_dependencies.h
  group Harmony3/Header Files/config/sam_d21_xpro_iar/driver/usb/usbfsv1
    ../src/config/sam_d21_xpro_iar/driver/usb/usbfsv1/: drv_usbfsv1.h
  group Harmony3/Header Files/config/sam_d21_xpro_iar/driver/usb/usbfsv1/src
    ../src/config/sam_d21_xpro_iar/driver/usb/usbfsv1/src/: drv_usbfsv1_variant_mapping.h drv_usbfsv1_local.h
  group Harmony3/Header Files/config/sam_d21_xpro_iar/usb
    ../src/config/sam_d21_xpro_iar/usb/: usb_host_client_driver.h usb_host_hub_interface.h usb_host.h usb_hub.h usb_device.h usb_common.h usb_chapter_9.h usb_device_cdc.h usb_cdc.h
  group Harmony3/Header Files/config/sam_d21_xpro_iar/usb/src
    ../src/config/sam_d21_xpro_iar/usb/src/: usb_device_local.h usb_device_mapping.h usb_device_function_driver.h usb_external_dependencies.h usb_device_cdc_local.h
  group Harmony3/Header Files/config/sam_d21_xpro_iar/system
    ../src/config/sam_d21_xpro_iar/system/: system.h system_common.h system_module.h
  group Harmony3/Header Files/config/sam_d21_xpro_iar/system/int
    ../src/config/sam_d21_xpro_iar/system/int/: sys_int.h sys_int_mapping.h
  group Harmony3/Header Files/config/sam_d21_xpro_iar/system/debug
    ../src/config/sam_d21_xpro_iar/system/debug/: sys_debug.h
  group Harmony3/Header Files/config/sam_d21_xpro_iar/osal
    ../src/config/sam_d21_xpro_iar/osal/: osal.h osal_definitions.h osal_impl_basic.h
  group Harmony3/Header Files/packs/ATSAMD21J18A_DFP
    ../src/packs/ATSAMD21J18A_DFP/: samd21j18a.h
  group Harmony3/Header Files/packs/ATSAMD21J18A_DFP/component
    ../src/packs/ATSAMD21J18A_DFP/component/: ac.h adc.h dac.h dmac.h dsu.h eic.h evsys.h gclk.h hmatrixb.h i2s.h mtb.h nvmctrl.h pac.h pm.h port.h ptc.h rtc.h sercom.h sysctrl.h tc.h tcc.h usb.h wdt.h
  group Harmony3/Header Files/packs/ATSAMD21J18A_DFP/instance
    ../src/packs/ATSAMD21J18A_DFP/instance/: ac.h adc.h dac.h dmac.h dsu.h eic.h evsys.h gclk.h i2s.h mtb.h nvmctrl.h pac0.h pac1.h pac2.h pm.h port.h ptc.h rtc.h sbmatrix.h sercom0.h sercom1.h sercom2.h sercom3.h sercom4.h sercom5.h sysctrl.h tc3.h tc4.h tc5.h tc6.h tc7.h tcc0.h tcc1.h tcc2.h usb.h wdt.h
  group Harmony3/Header Files/packs/ATSAMD21J18A_DFP/pio
    ../src/packs/ATSAMD21J18A_DFP/pio/: samd21j18a.h
  group Harmony3/Header Files/packs/CMSIS/CMSIS/Core/Include
    ../src/packs/CMSIS/CMSIS/Core/Include/: cmsis_version.h cmsis_compiler.h cmsis_iccarm.h cmsis_gcc.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h core_cm0plus.h mpu_armv7.h cachel1_armv7.h
  group Harmony3/Source Files
    ../src/: main.c app.c
  group Harmony3/Source Files/config/sam_d21_xpro_iar
    ../src/config/sam_d21_xpro_iar/: initialization.c interrupts.c exceptions.c startup_iar.c usb_device_init_data.c tasks.c
  group Harmony3/Source Files/config/sam_d21_xpro_iar/bsp
    ../src/config/sam_d21_xpro_iar/bsp/: bsp.c
  group Harmony3/Source Files/config/sam_d21_xpro_iar/peripheral/nvmctrl
    ../src/config/sam_d21_xpro_iar/peripheral/nvmctrl/: plib_nvmctrl.c
  group Harmony3/Source Files/config/sam_d21_xpro_iar/peripheral/evsys
    ../src/config/sam_d21_xpro_iar/peripheral/evsys/: plib_evsys.c
  group Harmony3/Source Files/config/sam_d21_xpro_iar/peripheral/port
    ../src/config/sam_d21_xpro_iar/peripheral/port/: plib_port.c
  group Harmony3/Source Files/config/sam_d21_xpro_iar/peripheral/clock
    ../src/config/sam_d21_xpro_iar/peripheral/clock/: plib_clock.c
  group Harmony3/Source Files/config/sam_d21_xpro_iar/peripheral/nvic
    ../src/config/sam_d21_xpro_iar/peripheral/nvic/: plib_nvic.c
  group Harmony3/Source Files/config/sam_d21_xpro_iar/stdio
    ../src/config/sam_d21_xpro_iar/stdio/: iar_monitor.c
  group Harmony3/Source Files/config/sam_d21_xpro_iar/driver/usb/usbfsv1/src
    ../src/config/sam_d21_xpro_iar/driver/usb/usbfsv1/src/: drv_usbfsv1.c drv_usbfsv1_device.c
  group Harmony3/Source Files/config/sam_d21_xpro_iar/usb/src
    ../src/config/sam_d21_xpro_iar/usb/src/: usb_device.c usb_device_cdc.c usb_device_cdc_acm.c
  group Harmony3/Source Files/config/sam_d21_xpro_iar/system/int
    ../src/config/sam_d21_xpro_iar/system/int/src/: sys_int.c
  group Harmony3/Linker File
    ../src/config/sam_d21_xpro_iar/: flash.icf
